<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DCM_RusElProm.OP.OLED.CM4.ewp</path>
    </project>
    <batchBuild />
</workspace>
