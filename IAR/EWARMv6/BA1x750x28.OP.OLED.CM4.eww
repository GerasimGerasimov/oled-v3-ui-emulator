<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BA1x750x28.OP.OLED.CM4.ewp</path>
    </project>
    <batchBuild />
</workspace>
