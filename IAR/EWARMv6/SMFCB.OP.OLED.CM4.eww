<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SMFCB.OP.OLED.CM4.ewp</path>
    </project>
    <batchBuild />
</workspace>
