<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PTC_KZ.OP.OLED.CM4.v1.1.0.ewp</path>
    </project>
    <batchBuild />
</workspace>
