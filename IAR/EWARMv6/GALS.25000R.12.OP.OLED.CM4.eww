<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GALS.25000R.12.OP.OLED.CM4.ewp</path>
    </project>
    <batchBuild />
</workspace>
