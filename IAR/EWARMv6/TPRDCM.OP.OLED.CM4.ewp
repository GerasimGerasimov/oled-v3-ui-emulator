# IAR project TPRDCM.OP.OLED.CM4.ewp, settings and files
configuration STM32F407IGT6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HEAP_SIZE_SET
  ICCARM.CCDiagSuppress: PE815, PE375
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Device\ST\STM32F4xx\Include; ..\STM32F4xx_StdPeriph_Driver\inc; ..\STM32F4xx_StdPeriph_Driver; ..\IntmashLib; ..\OP.OLED.CM4; ..\STM32F4xx_Intmash_Driver; ..\UserData; ..\Resources; ..\Helpers; ..\Drivers; ..\Drivers\Display; ..\Drivers\Communications; ..\Drivers\Keyboard; ..\Drivers\Timer; ..\Drivers\Leds; ..\Drivers\Leds\Link; ..\Drivers\Leds\Alarm; ..\Drivers\Leds\Warning; ..\Drivers\Resources; ..\Drivers\DIN; ..\Drivers\DOUT; ..\..\MCU\IDrivers; ..\..\MCU\GraphicsFunctions; ..\..\MCU\Fonts; ..\..\MCU\App; ..\..\MCU\Router; ..\..\MCU\Components; ..\..\MCU\Msg; ..\..\MCU\DevicePollManager; ..\..\MCU\Pages; ..\..\MCU\Events; ..\..\MCU\Parameters; ..\..\MCU\Slots; ..\..\MCU\ini; ..\..\MCU\Helpers; ..\..\MCU\Modbus; ..\..\MCU\DevicesValues; ..\..\MCU\Pages\MainMenu; ..\..\MCU\Pages\Counters; ..\..\MCU\Pages\EditValue; ..\..\MCU\Pages\Home; ..\..\MCU\Pages\Help; ..\..\MCU\Pages\Alarms; ..\..\MCU\Pages\Warning; ..\..\MCU\Pages\OperateStatus; ..\..\MCU\Pages\BasicSettings; ..\..\MCU\Pages\BasicProtectionsSettings; ..\..\MCU\Pages\PageMemoryState; ..\..\MCU\Pages\Sensors; ..\..\MCU\Pages\NetworkSettings; ..\..\MCU\Resources; ..\..\MCU\StateControllers; ..\..\MCU\StateControllers\Alarms; ..\..\MCU\StateControllers\Warnings; ..\..\MCU\CmdSender; ..\..\MCU\SetValueSelector; ..\..\MCU\Pages\ParameterListEdit; ..\..\MCU\Pages\PanelSettings; ..\..\MCU\Pages\Calibration; ..\..\MCU\Pages\ControlSettings; ..\..\MCU\Pages\Discretes; ..\..\MCU\SetValueSelector; ..\..\MCU\Pages\CleanSettings; ..\..\MCU\IDrivers\MemWrite; ..\Drivers\MemWrite
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: TPRDCM.OP.OLED.CM4.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers
    ../Drivers/MemWrite/: MemWrite.cpp MemWrite.h
  group Drivers/Communications
    ../Drivers/Communications/: com_master_driver.cpp
  group Drivers/DIN
    ../Drivers/DIN/: internal_din.cpp
  group Drivers/Display
    ../Drivers/Display/: display_dc.c display_driver.cpp ssd1305.c
  group Drivers/DOUT
    ../Drivers/DOUT/: internal_dout.cpp
  group Drivers/Keyboard
    ../Drivers/Keyboard/: buttons.c KeyBoard.cpp KeyBoard_wrapper_cpp.cpp virtualKeyEvents.cpp
  group Drivers/Leds
    ../Drivers/Leds/: leds_timer_wrapper.c leds_timer_wrapper_cpp.cpp
    ../Drivers/Leds/Link/: link_led.cpp
  group Drivers/Leds/Alarm
    ../Drivers/Leds/Alarm/: LedAlarms.cpp
  group Drivers/Leds/Warning
    ../Drivers/Leds/Warning/: LedWarnings.cpp
  group Drivers/Resources
    ../Drivers/Resources/: os_resources.cpp resources_wrapper.cpp
  group Drivers/Timer
    ../Drivers/Timer/: timer_wrapper.c timer_wrapper_cpp.cpp
  group EWARMv6
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group Helpers
    ../Helpers/: str.c
  group IntmashLib
    ../IntmashLib/: id.c ModbusSlave.c
  group MCU/App
    ../../MCU/App/: app.cpp
  group MCU/CmdSender
    ../../MCU/CmdSender/: CmdSender.cpp
  group MCU/Components
    ../../MCU/Components/: common.cpp FixedFooter.cpp FixedHeader.cpp HeaderLabel.cpp Label.cpp LabelTime.cpp LinkedTagLabel.cpp LinkLabel.cpp NumericEdit.cpp Pages.cpp ParamListSelector.cpp TagLine.cpp TagLineTime.cpp TagLineVarSize.cpp TComponentListVertical.cpp TComponentsContainer.cpp TVerticalContainer.cpp TwoTagLine.cpp WrappedText.cpp
  group MCU/DevicePollManager
    ../../MCU/DevicePollManager/: DevicePollManager.cpp Slot.cpp
  group MCU/DevicesValues
    ../../MCU/DevicesValues/: DevicesValuesHandler.cpp HandleSubscribers.cpp
  group MCU/Fonts
    ../../MCU/Fonts/: MSSansSerifBold14.cpp TMCUFonts.cpp TMCUText.cpp Verdana12.cpp
  group MCU/GraphicsFunctions
    ../../MCU/GraphicsFunctions/: graphics.cpp
  group MCU/Helpers
    ../../MCU/Helpers/: crc16.c utils.cpp
  group MCU/ini
    ../../MCU/ini/: IniResources.cpp IniSlotsProps.cpp parser.cpp
  group MCU/Modbus
    ../../MCU/Modbus/: AppModbusSlave.cpp
  group MCU/Msg
    ../../MCU/Msg/: msg.cpp
  group MCU/Msg/IDrivers
    ../../MCU/IDrivers/: icommastert.h iresources.h
  group MCU/Pages
    ../../MCU/Pages/Alarms/: PageAlarms.cpp
    ../../MCU/Pages/BasicProtectionsSettings/: PageBasicProtectionsSettings.cpp
    ../../MCU/Pages/BasicSettings/: PageBasicSettings.cpp
    ../../MCU/Pages/Calibration/: PageCalibration.cpp
    ../../MCU/Pages/CleanSettings/: PageCleanSettings.cpp
    ../../MCU/Pages/ControlParameters/: PageControlParameters.cpp
    ../../MCU/Pages/ControlSettings/: PageControlSettings.cpp
    ../../MCU/Pages/EditValue/: PageEditValue.cpp
    ../../MCU/Pages/Excitation/: PageExcitation.cpp
    ../../MCU/Pages/Help/: PageHelp.cpp
    ../../MCU/Pages/Home/: PageHome.cpp
    ../../MCU/Pages/InformationSignals/: PageInformationSignals.cpp
    ../../MCU/Pages/MainMenu/: PageMainMenu.cpp
    ../../MCU/Pages/NetworkSettings/: PageNetworkSettings.cpp
    ../../MCU/Pages/Nominals/: PageNominal.cpp
    ../../MCU/Pages/OperateStatus/: PageOperateStatus.cpp
    ../../MCU/Pages/PanelSettings/: PagePanelSettings.cpp
    ../../MCU/Pages/ParameterListEdit/: PageParameterListEdit.cpp PageParameterListEdit.h
    ../../MCU/Pages/Ready/: PageReady.cpp
    ../../MCU/Pages/RegulatorSettings/: PageRegulatorSettings.cpp
    ../../MCU/Pages/Sensors/: PageSensors.cpp
    ../../MCU/Pages/ThermalProtection/: PageThermalProtection.cpp
    ../../MCU/Pages/Warning/: PageWarnings.cpp
  group MCU/Pages/Discretes
    ../../MCU/Pages/Discretes/: PageDIn.cpp PageDIn.h PageInOut.cpp PageInOut.h TPageDOut.cpp TPageDOut.h
  group MCU/Parameters
    ../../MCU/Parameters/: generalcase.cpp inistring.cpp parameters.cpp ParametersUtils.cpp scaleutils.cpp signal.cpp signalfactory.cpp TBit.cpp TFloat.cpp TPrmList.cpp TS16bit.cpp TU16bit.cpp TU32BIT.cpp TU8BIT.cpp vars.cpp
  group MCU/Resources
    ../../MCU/Resources/: resources.cpp
  group MCU/Router
    ../../MCU/Router/: Router.cpp
  group MCU/SetValueSelector
    ../../MCU/SetValueSelector/: SetValueSelector.cpp SetValueSelector.h
  group MCU/Slots
    ../../MCU/Slots/: CommonSlotHandler.cpp CreateCustomSlot.cpp CreateSlotsByStart.cpp
  group MCU/StateControllers
    ../../MCU/StateControllers/: StateControllers.h
  group MCU/StateControllers/Alarms
    ../../MCU/StateControllers/Alarms/: Alarms.cpp
  group MCU/StateControllers/Warnings
    ../../MCU/StateControllers/Warnings/: Warnings.cpp
  group OP.OLED.CM4
    ../OP.OLED.CM4/: init.c livecontrol.c main.cpp stm32f4xx_it.c
  group StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group STM32F4xx_Intmash_Driver
    ../STM32F4xx_Intmash_Driver/: STM32F4xx_Intmash_Flash.c STM32F4xx_intmash_MBbasicCommands.c STM32F4xx_Intmash_USART.c
  group UserData
    ../UserData/: app_check_info.c CalibrationData.c flashdata.c ModbusMasterConf.c ModbusSlaveConf.c ramdata.c
